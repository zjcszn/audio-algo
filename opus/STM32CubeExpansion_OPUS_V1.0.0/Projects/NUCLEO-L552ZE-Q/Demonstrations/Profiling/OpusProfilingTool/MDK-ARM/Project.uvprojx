# Keil uVision project Project.uvprojx, settings and files
target OPT_FW (6140000::V6.14::ARMCLANG)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=2 v6LangP=3 wLevel=3
  c define: STM32L552xx,USE_HAL_DRIVER,HAVE_CONFIG_H,ARM_MATH_CM4,OPUS_ARM_ASM
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc;../../../../../../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/BSP/STM32L5xx_Nucleo;../../../../../../Middlewares/ST/STCmdP/inc;../../../../../../Middlewares/Third_Party/Opus/celt;../../../../../../Middlewares/Third_Party/Opus/celt/arm;../../../../../../Middlewares/Third_Party/Opus/include;../../../../../../Middlewares/Third_Party/Opus/silk;../../../../../../Middlewares/Third_Party/Opus/silk/arm;../../../../../../Middlewares/Third_Party/Opus/silk/fixed;../../../../../../Middlewares/Third_Party/Opus/src;../../../../../../Middlewares/Third_Party/Opus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: stm32l552xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l552xx.s
  group Application/User
    ../Src/: main.c opus_interface.c stm32xx_it.c uart_protocol_interface.c opt_cmd_handlers.c stcmdp_manager.c
  group Drivers/BSP/STM32L5xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L5xx_Nucleo/: stm32l5xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32l5xx.c
  group Drivers/STM32L5xx_HAL_Driver
    ../../../../../../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_exti.c stm32l5xx_hal_flash.c stm32l5xx_hal_gpio.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_icache.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_rcc_ex.c
  group Middlewares/ST/STCmdP
    ../../../../../../Middlewares/ST/STCmdP/src/: STCmdP.c
  group Middlewares/Third Party/Opus/celt
    ../../../../../../Middlewares/Third_Party/Opus/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c
  group Middlewares/Third Party/Opus/celt/arm
    ../../../../../../Middlewares/Third_Party/Opus/celt/arm/: arm_celt_map.c armcpu.c
  group Middlewares/Third Party/Opus/silk
    ../../../../../../Middlewares/Third_Party/Opus/silk/: A2NLSF.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c CNG.c code_signs.c control_audio_bandwidth.c control_codec.c control_SNR.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c HP_variable_cutoff.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c LP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c NLSF2A.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NSQ.c NSQ_del_dec.c pitch_est_tables.c PLC.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_down_FIR.c resampler_private_IIR_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_gain.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c VAD.c VQ_WMat_EC.c
  group Middlewares/Third Party/Opus/silk/fixed
    ../../../../../../Middlewares/Third_Party/Opus/silk/fixed/: apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c
  group Middlewares/Third Party/Opus/src
    ../../../../../../Middlewares/Third_Party/Opus/src/: analysis.c mlp.c mlp_data.c opus.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c repacketizer.c
software components: CMSIS:CORE 5.4.0
