# Keil uVision project npp.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: npp (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,
  c include: .\MELPe;.\MELPe\ARM;.\DSP\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./MELPe/: classify.c coeff.c coeff.h constant.h cprv.h dsp_sub.c dsp_sub.h fec_code.c fec_code.h fft_lib.c fft_lib.h fs_lib.c fs_lib.h fsvq_cb.c fsvq_cb.h global.c global.h harm.c harm.h lpc_lib.c lpc_lib.h macro.h mat_lib.c mat_lib.h math_lib.c math_lib.h mathdp31.c mathdp31.h mathhalf.h melp_ana.c melp_chn.c melp_sub.c melp_sub.h melp_syn.c melpe_pitch.c melpe_pitch.h MelpeC.c msvq_cb.c msvq_cb.h npp.c npp.h pit_lib.c pit_lib.h postfilt.c postfilt.h qnt12.c qnt12.h qnt12_cb.c qnt12_cb.h sc12dec.c sc12enc.c sc24dec.c sc24enc.c sc1200.c sc1200.h transcode.c transcode.h vq_lib.c vq_lib.h
    ./MELPe/ARM/: mathhalf.c Retarget.c
  group arm_math_lib
    ./DSP/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.4.0
